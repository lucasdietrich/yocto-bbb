require linux.inc

FILESEXTRAPATHS:prepend := "${THISDIR}/files/6.10:"

PV ?= "6.10.6"
SRC_URI[sha256sum] = "774698422ee54c5f1e704456f37c65c06b51b4e9a8b0866f34580d86fef8e226"