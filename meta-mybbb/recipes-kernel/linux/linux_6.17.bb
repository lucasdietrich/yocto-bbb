require linux.inc

FILESEXTRAPATHS:prepend := "${THISDIR}/files/6.17:"

PV ?= "6.17"
SRC_URI[sha256sum] = "9b607166a1c999d8326098121222feb080a20a3253975fcdfa2de96ba7f757a7"